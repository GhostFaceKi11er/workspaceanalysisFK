Commit message: single TCP IK

File: models/M1/M1_full_load.urdf (robot description, URDF)
Before this commit: robot M1_description, 27 links, 26 joints
Links:
- link rightHandEE: mass 5.0 -> 10.0
